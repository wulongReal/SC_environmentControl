# Keil uVision project HM_CoreP.uvprojx, settings and files
target CoreP_NoBT (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CoreP_NoBT +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,PLATFORM_F103
  c include: ..\Libaries\CMSIS_MDK\CM3\CoreSupport;..\Libaries\CMSIS_MDK\CM3\DeviceSupport\ST\STM32F10x;..\Libaries\STM32F10x_StdPeriph_Driver\inc;..\Libaries\USB-FS-Device_Driver\inc;..\APP\inc;..\RT-Thread-1.2.2\include;..\RT-Thread-1.2.2\components\drivers\include;..\RT-Thread-1.2.2\components\drivers\include\drivers;..\FreeModbus\modbus\include;..\FreeModbus\modbus\rtu;..\FreeModbus\port
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source
    ../APP/src/: app.c app_task.c stm32f10x_it.c usart.c gpio.c Vars.c RS232.c CAN.c dataflash.c esim.c adc.c dac.c rtc.c lte720.c envir.c DS1302.c EP_MODBUS.c
    ../RT-Thread-1.2.2/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group Header
    ../APP/inc/: platform.h ver.h stm32f10x_conf.h stm32f10x_it.h bsp.h app_task.h cpuusage.h gpio.h usart.h delay_conf.h rtconfig.h vars.h CAN.h RS232.h
    ../: README.txt
  group StdPeriph_Driver
    ../Libaries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libaries/CMSIS_MDK/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libaries/CMSIS_MDK/CM3/CoreSupport/: core_cm3.c
  group RT-Thread Kernel
    ../RT-Thread-1.2.2/src/: clock.c cpuusage.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread Drivers
    ../RT-Thread-1.2.2/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c wrokqueue.c
    ../RT-Thread-1.2.2/components/drivers/serial/: serial.c
    ../RT-Thread-1.2.2/components/drivers/misc/: pin.c
  group FreeModbusSlave
    ../FreeModbus/modbus/: mb.c
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../FreeModbus/port/rtt/: port.c portevent.c portserial.c porttimer.c
    ../FreeModbus/port/: user_mb_app.c
  group FreeModbusMaster
    ../FreeModbus/modbus/: mb_m.c
    ../FreeModbus/modbus/rtu/: mbrtu_m.c
    ../FreeModbus/modbus/functions/: mbfuncholding_m.c mbfunccoils_m.c mbfuncinput_m.c mbfuncdisc_m.c
    ../FreeModbus/port/rtt/: portevent_m.c portserial_m.c porttimer_m.c
    ../FreeModbus/port/: user_mb_app_m.c
target CoreP_BOOT (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HM_CoreP_BL +hex
  AfterMake: fromelf --m32combined --output=./Output/Boot/_HM_CoreP.s19  ./Output/Boot/HM_CoreP_BL.axf
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,BOOT,PLATFORM_F103
  c include: ..\Libaries\CMSIS_MDK\CM3\CoreSupport;..\Libaries\CMSIS_MDK\CM3\DeviceSupport\ST\STM32F10x;..\Libaries\STM32F10x_StdPeriph_Driver\inc;..\Libaries\USB-FS-Device_Driver\inc;..\BSP\inc;..\APP\inc;..\RT-Thread-1.2.2\include;..\RT-Thread-1.2.2\components\drivers\include;..\RT-Thread-1.2.2\components\drivers\include\drivers;..\FreeModbus\modbus\include;..\FreeModbus\modbus\rtu;..\FreeModbus\port
  memory RVCT4: ROM 0x8002400 size 0x1dc00
  memory RVCT9: RAM 0x20000000 size 0x5000
target CoreP_TraPro (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: HM_CoreP_TR
  AfterMake: fromelf --m32combined --output=./Output/TrPro/_HM_CoreP_TR.s19  ./Output/TrPro/HM_CoreP_TR.axf
  AfterMake: clr_tra.bat
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,BOOT,PLATFORM_F103,TRA_PRO
  c include: as above
  memory RVCT4: ROM 0x8002400 size 0x1dc00
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.0.1
